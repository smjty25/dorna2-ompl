Commit message: fa

File: resources/urdf/DornaTA.urdf (robot description, URDF)
Before this commit: robot DornaTA, 8 links, 7 joints
Links:
- removed link rail_link
Joints:
- removed joint rail_link_joint
